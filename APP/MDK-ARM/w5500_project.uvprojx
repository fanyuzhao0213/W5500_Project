# Keil uVision project w5500_project.uvprojx, settings and files
target w5500_project_A (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: w5500_project_A +hex
  AfterMake: fromelf --bin -o ./w5500_project_A.bin ./w5500_project/w5500_project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,VECT_TAB_OFFSET=0x0000C000
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Application/RTT;../Application/W5500;..\Application\W5500;..\Application\W5500\Internet\DHCP;..\Application\W5500\Internet;..\Application\W5500\Internet\DNS;..\Application\MQTT\inc;..\Application\MQTT\paho;..\Application\FreeRTOS_CLI;..\Application\FreeRTOS_CLI\inc;..\Application\OTA
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\w5500_project\w5500_project_A.sct
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group RTT
    ../Application/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group W5500
    ../Application/W5500/: netconf.c socket.c w5500.c w5500_conf.c wizchip_conf.c tcp_client.c
    ../Application/W5500/Internet/DHCP/: dhcp.c
    ../Application/W5500/Internet/DNS/: dns.c
  group MQTT
    ../Application/MQTT/src/: mqtt_client.c mqtt_port.c mqtt_queue.c mqtt_task.c timer_task.c mqtt_exception.c
    ../Application/MQTT/paho/: MQTTClient.c MQTTConnectClient.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group FreeRtos_CLI
    ../Application/FreeRTOS_CLI/: FreeRTOS_CLI.c
    ../Application/FreeRTOS_CLI/src/: cli_task.c cli_commands.c
  group OTA
    ../Application/OTA/: flash_driver.c ota_client.c ota_example.c ota_params.c
target w5500_project_B (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: w5500_project_B +hex
  AfterMake: fromelf --bin -o ./w5500_project_B.bin ./w5500_project/w5500_project_B.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,VECT_TAB_OFFSET=0x00084000
  c include: as above
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  scatter file: .\w5500_project\w5500_project_B.sct
software components: CMSIS:CORE 4.3.0
